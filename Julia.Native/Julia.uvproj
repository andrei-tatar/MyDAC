# Keil uVision project Julia.uvproj, settings and files
target Julia (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Julia +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=12000000UL
  c include: .\;.\Libraries\CMSIS\;.\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s stm32f4xx_it.c system_stm32f4xx.c
  group src
    ./: main.c usart.c oled.c remote.c i2c.c
  group drv
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_i2c.c
